# Keil uVision project f072_t1.uvprojx, settings and files
target f072_t1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: f072_t1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072xB
  c include: ../Inc;    ../Drivers/STM32F0xx_HAL_Driver/Inc;    ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;    ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group Application/User
    ../Src/: main.c i2c.c usart.c stm32f0xx_hal_msp.c dma.c tim.c rtc.c crc.c iwdg.c stm32f0xx_it.c adc.c spi.c gpio.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_adc.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_rtc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_flash.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_dma.c stm32f0xx_hal_tim.c stm32f0xx_hal_pwr.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_crc.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group doc
    ../: README.md
  group lcd2004
    ../Src/: LiquidCrystal.cpp
  group stdio_drv
    ../Src/: retarget_io_drv.c
software components: CMSIS:CORE 5.0.2, Compiler:I/O:STDOUT 1.2.1
